<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_components_memory_data_flash_at45dbx_unit_tests_evk1105.ewp</path>
	</project>
</workspace>
