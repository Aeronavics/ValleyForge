# IAR project common_services_basic_sleepmgr_example_evk1101.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../clock; ..; ../../../../../../avr32/boards/evk1101; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/rtc; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../..; ../../../../../utils; ../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/eic
    ../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/rtc
    ../../../../../../avr32/drivers/rtc/: rtc.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1101
    ../../../../../../avr32/boards/evk1101/: led.c init.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../uc3/: sleepmgr.c
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_uc3a_uc3b.c
  group common/services/clock/uc3b0_b1
    ../../../../clock/uc3b0_b1/: sysclk.c
