<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_cdc_device_example_uc3_c2_xplained.ewp</path>
	</project>
</workspace>
