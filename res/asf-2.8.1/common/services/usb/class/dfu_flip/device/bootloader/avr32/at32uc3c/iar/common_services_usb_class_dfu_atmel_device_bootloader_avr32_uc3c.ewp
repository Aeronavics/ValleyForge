# IAR project common_services_usb_class_dfu_atmel_device_bootloader_avr32_uc3c.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../intc; ../../../../../../../../../../avr32/boards/dummy; ../../../../../../../../../../avr32/drivers/scif; ../../../..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../../avr32/drivers/pm; ../../../../..; ../../conf; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/drivers/ast; ../../../../../../../../../../avr32/utils; ../../../../../../../../../utils; ../../../../../../../../../../avr32/services/freq_detect; ../../../../../../../../clock; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../../isp/flip/uc3; .; ../../../../../../../../../boards; ../..; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../isp/flip; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkat32uc3c-isp.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/scif
    ../../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/usbc
    ../../../../../../../../../../avr32/drivers/usbc/: usbc_device.c
  group avr32/drivers/ast
    ../../../../../../../../../../avr32/drivers/ast/: ast.c
  group avr32/services/freq_detect
    ../../../../../../../../../../avr32/services/freq_detect/: freq_detect.c
  group common/services/clock/uc3c
    ../../../../../../../../clock/uc3c/: sysclk.c pll.c osc.c
  group common/services/isp/flip/uc3
    ../../../../../../../../isp/flip/uc3/: isp.c boot.s82
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/dfu_flip/device
    ../../../../: udi_dfu_atmel_desc.c udi_dfu_atmel.c
  group common/services/usb/class/dfu_flip/device/bootloader/avr32
    ../../: main.c
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/intc
    ../../intc/: intc.c
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/at32uc3c
    ../: sysclk_auto.c
