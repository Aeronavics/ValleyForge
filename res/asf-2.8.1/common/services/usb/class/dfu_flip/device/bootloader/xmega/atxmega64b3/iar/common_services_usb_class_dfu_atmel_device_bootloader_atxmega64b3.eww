<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_dfu_atmel_device_bootloader_atxmega64b3.ewp</path>
	</project>
</workspace>
