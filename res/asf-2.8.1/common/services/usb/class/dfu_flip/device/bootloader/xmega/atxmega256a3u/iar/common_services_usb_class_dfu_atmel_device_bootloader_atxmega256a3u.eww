<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_dfu_atmel_device_bootloader_atxmega256a3u.ewp</path>
	</project>
</workspace>
