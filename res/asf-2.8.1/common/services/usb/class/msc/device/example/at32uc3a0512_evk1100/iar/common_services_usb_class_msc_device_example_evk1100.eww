<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_example_evk1100.ewp</path>
	</project>
</workspace>
