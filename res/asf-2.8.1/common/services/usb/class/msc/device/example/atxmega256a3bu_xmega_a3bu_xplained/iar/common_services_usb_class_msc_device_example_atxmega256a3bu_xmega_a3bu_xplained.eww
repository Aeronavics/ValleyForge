<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_example_atxmega256a3bu_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
