<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_example_xmega_b1_xplained.ewp</path>
	</project>
</workspace>
