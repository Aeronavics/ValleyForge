<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_device_mouse_unit_tests_stk600_atxmega256a3bu.ewp</path>
	</project>
</workspace>
