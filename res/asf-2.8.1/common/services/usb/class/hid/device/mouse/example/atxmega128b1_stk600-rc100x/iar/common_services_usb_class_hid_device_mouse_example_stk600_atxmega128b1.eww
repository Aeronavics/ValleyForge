<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_device_mouse_example_stk600_atxmega128b1.ewp</path>
	</project>
</workspace>
