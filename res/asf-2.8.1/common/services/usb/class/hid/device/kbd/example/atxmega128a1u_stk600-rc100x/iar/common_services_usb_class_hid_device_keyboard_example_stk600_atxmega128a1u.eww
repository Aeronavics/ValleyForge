<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_device_keyboard_example_stk600_atxmega128a1u.ewp</path>
	</project>
</workspace>
