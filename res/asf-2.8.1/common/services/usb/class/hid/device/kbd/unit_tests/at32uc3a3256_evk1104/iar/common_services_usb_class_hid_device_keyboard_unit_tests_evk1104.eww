<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_device_keyboard_unit_tests_evk1104.ewp</path>
	</project>
</workspace>
