<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_spi_master_example_xplain.ewp</path>
	</project>
</workspace>
