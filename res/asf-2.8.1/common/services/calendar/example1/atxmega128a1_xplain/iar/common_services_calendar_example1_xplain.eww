<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_calendar_example1_xplain.ewp</path>
	</project>
</workspace>
