<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_calendar_unit_tests_xplain.ewp</path>
	</project>
</workspace>
