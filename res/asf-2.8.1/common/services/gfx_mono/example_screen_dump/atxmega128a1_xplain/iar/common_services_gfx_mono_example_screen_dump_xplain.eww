<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_gfx_mono_example_screen_dump_xplain.ewp</path>
	</project>
</workspace>
