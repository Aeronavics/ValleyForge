<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_cpu_example_uc3l_ek.ewp</path>
	</project>
</workspace>
