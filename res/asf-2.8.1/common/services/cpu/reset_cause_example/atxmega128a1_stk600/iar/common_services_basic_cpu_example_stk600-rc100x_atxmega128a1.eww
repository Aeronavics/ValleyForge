<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_cpu_example_stk600-rc100x_atxmega128a1.ewp</path>
	</project>
</workspace>
