<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example1_evk1104.ewp</path>
	</project>
</workspace>
