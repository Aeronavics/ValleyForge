<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example3_uc3l_ek.ewp</path>
	</project>
</workspace>
