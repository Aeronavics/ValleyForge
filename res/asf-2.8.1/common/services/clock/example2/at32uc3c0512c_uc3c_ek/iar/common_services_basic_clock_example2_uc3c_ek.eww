<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_uc3c_ek.ewp</path>
	</project>
</workspace>
