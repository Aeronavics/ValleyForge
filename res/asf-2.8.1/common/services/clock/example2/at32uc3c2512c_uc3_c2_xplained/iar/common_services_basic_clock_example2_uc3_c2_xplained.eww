<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_uc3_c2_xplained.ewp</path>
	</project>
</workspace>
