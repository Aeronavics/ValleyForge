<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_serial_example_xplain.ewp</path>
	</project>
</workspace>
