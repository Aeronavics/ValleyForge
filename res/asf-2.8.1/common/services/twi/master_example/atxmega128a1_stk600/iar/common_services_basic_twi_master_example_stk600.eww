<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_twi_master_example_stk600.ewp</path>
	</project>
</workspace>
