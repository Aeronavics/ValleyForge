<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_twi_master_example_uc3l_ek.ewp</path>
	</project>
</workspace>
