<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_adcifb_example1_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
