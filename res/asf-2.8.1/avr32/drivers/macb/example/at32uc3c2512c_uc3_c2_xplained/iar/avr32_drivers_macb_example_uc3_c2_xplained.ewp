# IAR project avr32_drivers_macb_example_uc3_c2_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_C2_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../boards/uc3_c2_xplained; ../../../../../components/ethernet_phy/rtl8201; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../scif; ../../../../../utils/debug; ../../..; ../../../../../components/ethernet_phy; ../../../../../../common/boards; ../../../../usart; ../../../../flashc; ../../../../../boards; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../../services/delay; ../../../../gpio; ../../../../intc; ../../../../pm; ../../../../../components/ethernet_phy/dp83848; ../../../../../components/ethernet_phy/dummy_phy; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_C2_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3c/2512c/iar/lnkuc3c2512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/macb
    ../../../: macb.c
  group avr32/drivers/macb/example
    ../../: macb_example.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3c.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/delay
    ../../../../../services/delay/: delay.c
