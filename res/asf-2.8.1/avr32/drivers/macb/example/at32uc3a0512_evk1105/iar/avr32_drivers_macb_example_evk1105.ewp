# IAR project avr32_drivers_macb_example_evk1105.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../components/ethernet_phy/rtl8201; ../../../../../components/ethernet_phy/dummy_phy; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../../utils/debug; ../../..; ../../../../../components/ethernet_phy; ../../../../../../common/boards; ../../../../usart; ../../../../flashc; ../../../../../boards; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../../services/delay; ../../../../gpio; ../../../../intc; ../../../../pm; ../../../../../components/ethernet_phy/dp83848; ..; ../../../../../boards/evk1105; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/macb
    ../../../: macb.c
  group avr32/drivers/macb/example
    ../../: macb_example.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/delay
    ../../../../../services/delay/: delay.c
