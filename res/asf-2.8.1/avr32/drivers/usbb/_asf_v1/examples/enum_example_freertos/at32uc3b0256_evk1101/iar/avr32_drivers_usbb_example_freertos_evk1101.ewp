# IAR project avr32_drivers_usbb_example_freertos_evk1101.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1700
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x2800
  ICCAVR32.CCDefines: BOARD=EVK1101; FREERTOS_USED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../enum/device; ../../../../../../../boards; ../../../../../../pm; ../../../../../../../services/usb/_asf_v1; ../../../..; ../../../../../../../utils/debug; ../../../../../../tc; ../../../../../../../utils; ../../../../../../../boards/evk1101; ../../../../../../gpio; ../../../enum/device; ../../../../../../../../common/utils; ../../../../../../../../thirdparty/freertos/source/include; ../../../enum; ../../freertos; ../../../../../../cpu/cycle_counter; ../../../../enum; ../../../../enum/host; ../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3; ../../..; ../../../../../../../../common/boards; ../../../../../../usart; ../../../../../../flashc; ../../../../../../../utils/preprocessor; ../../../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; FREERTOS_USED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/examples
    ../../../: enum_example.c device_template_task.c host_template_task.c
  group avr32/drivers/usbb/_asf_v1/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../enum/host/: usb_host_enum.c usb_host_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/intc
    ../../../../../../intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../tc/: tc.c
  group avr32/drivers/flashc
    ../../../../../../flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../usart/: usart.c
  group avr32/boards/evk1101
    ../../../../../../../boards/evk1101/: led.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
  group thirdparty/freertos/source
    ../../../../../../../../thirdparty/freertos/source/: tasks.c queue.c croutine.c timers.c list.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: write.c read.c port.c exception.s82
  group thirdparty/freertos/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/source/portable/memmang/: heap_3.c
