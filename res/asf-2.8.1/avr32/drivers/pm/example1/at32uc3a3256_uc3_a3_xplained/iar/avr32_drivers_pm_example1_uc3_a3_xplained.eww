<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_pm_example1_uc3_a3_xplained.ewp</path>
	</project>
</workspace>
