<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_pm_example2_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
