<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_pm_example2_evk1100.ewp</path>
	</project>
</workspace>
