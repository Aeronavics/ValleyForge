<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example3_uc3c_ek.ewp</path>
	</project>
</workspace>
