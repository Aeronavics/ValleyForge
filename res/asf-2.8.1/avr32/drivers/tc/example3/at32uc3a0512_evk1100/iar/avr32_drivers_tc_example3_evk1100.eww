<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example3_evk1100.ewp</path>
	</project>
</workspace>
