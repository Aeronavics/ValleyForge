<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example3_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
