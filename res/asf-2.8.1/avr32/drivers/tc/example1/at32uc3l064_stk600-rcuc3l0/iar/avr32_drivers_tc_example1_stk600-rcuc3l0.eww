<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example1_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
