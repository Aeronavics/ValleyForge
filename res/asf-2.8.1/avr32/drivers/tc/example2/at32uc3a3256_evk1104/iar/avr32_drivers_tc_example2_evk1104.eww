<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example2_evk1104.ewp</path>
	</project>
</workspace>
