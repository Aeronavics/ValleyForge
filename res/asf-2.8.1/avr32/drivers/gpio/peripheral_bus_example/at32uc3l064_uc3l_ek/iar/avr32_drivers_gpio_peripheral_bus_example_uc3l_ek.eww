<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_gpio_peripheral_bus_example_uc3l_ek.ewp</path>
	</project>
</workspace>
