<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_gpio_local_bus_example_uc3c_ek.ewp</path>
	</project>
</workspace>
