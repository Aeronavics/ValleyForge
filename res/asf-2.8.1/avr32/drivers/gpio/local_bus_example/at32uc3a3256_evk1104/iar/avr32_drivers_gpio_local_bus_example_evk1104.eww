<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_gpio_local_bus_example_evk1104.ewp</path>
	</project>
</workspace>
