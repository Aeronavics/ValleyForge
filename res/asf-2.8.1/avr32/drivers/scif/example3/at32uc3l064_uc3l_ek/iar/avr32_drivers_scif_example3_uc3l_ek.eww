<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_scif_example3_uc3l_ek.ewp</path>
	</project>
</workspace>
