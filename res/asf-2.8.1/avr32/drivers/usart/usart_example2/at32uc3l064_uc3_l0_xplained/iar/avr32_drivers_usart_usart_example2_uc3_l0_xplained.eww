<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_usart_usart_example2_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
