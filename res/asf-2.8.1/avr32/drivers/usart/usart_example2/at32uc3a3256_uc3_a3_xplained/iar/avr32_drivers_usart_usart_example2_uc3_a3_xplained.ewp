# IAR project avr32_drivers_usart_usart_example2_uc3_a3_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../gpio; ..; ../../../../../../common/services/clock; ../../../../../../common/boards; ../../..; ../../../../flashc; ../../../../../boards; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../../boards/uc3_a3_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3a3_a4
    ../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/usart
    ../../../: usart.c
  group avr32/drivers/usart/usart_example2
    ../../: usart_example2.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/boards/uc3_a3_xplained
    ../../../../../boards/uc3_a3_xplained/: init.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
