<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_twi_master_example_evk1105.ewp</path>
	</project>
</workspace>
