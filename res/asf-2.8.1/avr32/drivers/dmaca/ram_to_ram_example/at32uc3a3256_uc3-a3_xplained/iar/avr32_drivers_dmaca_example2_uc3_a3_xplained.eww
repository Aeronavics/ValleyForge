<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_dmaca_example2_uc3_a3_xplained.ewp</path>
	</project>
</workspace>
