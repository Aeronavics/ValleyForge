<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_hmatrix_example_uc3_a3_xplained.ewp</path>
	</project>
</workspace>
