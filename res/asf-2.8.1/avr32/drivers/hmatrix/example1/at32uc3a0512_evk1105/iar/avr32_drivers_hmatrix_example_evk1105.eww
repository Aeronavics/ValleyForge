<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_hmatrix_example_evk1105.ewp</path>
	</project>
</workspace>
