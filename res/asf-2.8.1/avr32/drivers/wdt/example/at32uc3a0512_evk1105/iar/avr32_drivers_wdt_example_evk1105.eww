<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_wdt_example_evk1105.ewp</path>
	</project>
</workspace>
