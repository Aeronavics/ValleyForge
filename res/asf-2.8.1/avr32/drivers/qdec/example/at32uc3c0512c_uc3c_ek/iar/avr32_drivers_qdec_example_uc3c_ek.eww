<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_qdec_example_uc3c_ek.ewp</path>
	</project>
</workspace>
