<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_eic_example3_evk1104.ewp</path>
	</project>
</workspace>
