<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_eic_example1_uc3l_ek.ewp</path>
	</project>
</workspace>
