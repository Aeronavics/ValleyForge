<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_cpu_cc_example_evk1104.ewp</path>
	</project>
</workspace>
