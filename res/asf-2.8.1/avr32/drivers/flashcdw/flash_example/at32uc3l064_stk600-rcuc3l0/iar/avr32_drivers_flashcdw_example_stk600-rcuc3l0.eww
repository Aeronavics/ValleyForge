<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_flashcdw_example_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
