<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_display_dip204_example_evk1100.ewp</path>
	</project>
</workspace>
