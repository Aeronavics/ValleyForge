<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_sdmmc_spi_unit_tests_uc3c_ek.ewp</path>
	</project>
</workspace>
