<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_audio_amp_tpa6130a2_example_evk1104.ewp</path>
	</project>
</workspace>
