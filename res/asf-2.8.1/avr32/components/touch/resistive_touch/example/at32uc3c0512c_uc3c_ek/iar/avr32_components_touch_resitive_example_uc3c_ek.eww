<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_touch_resitive_example_uc3c_ek.ewp</path>
	</project>
</workspace>
