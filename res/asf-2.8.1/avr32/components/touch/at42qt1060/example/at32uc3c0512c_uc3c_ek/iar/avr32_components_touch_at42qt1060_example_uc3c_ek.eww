<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_touch_at42qt1060_example_uc3c_ek.ewp</path>
	</project>
</workspace>
