<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_usb_hid_example_freertos_evk1100_asfv1.ewp</path>
	</project>
</workspace>
