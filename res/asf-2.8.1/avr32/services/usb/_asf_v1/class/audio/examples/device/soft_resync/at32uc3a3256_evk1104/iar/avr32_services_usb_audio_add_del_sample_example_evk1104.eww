<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_usb_audio_add_del_sample_example_evk1104.ewp</path>
	</project>
</workspace>
