<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_usb_audio_host_adaptif_example_evk1105.ewp</path>
	</project>
</workspace>
