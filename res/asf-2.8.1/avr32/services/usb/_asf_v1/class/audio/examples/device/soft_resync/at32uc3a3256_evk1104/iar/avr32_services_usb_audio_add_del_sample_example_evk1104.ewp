# IAR project avr32_services_usb_audio_add_del_sample_example_evk1104.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xC000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../../../../../../../../../common/boards; ../../../../../../hid; ../../../../../../../../../../drivers/rtc; ../../../../../../../../../../boards; ../../../../../../../../../../drivers/pdca; ../../../../../../../../../../components/audio; ../../../../../../../../../../drivers/twim; ../../../../../../../../../../drivers/pm; ../../../../../../../../../audio/audio_mixer; ../..; ../../../user_interface/controller; ../../../../../../../../../../components/touch/qt60168; ../../../../../../../../../../components/display/et024006dhu; ../../../../../../..; ../../../../../../../../../../drivers/ssc/i2s; ../../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../../utils/debug; ../../../../../../../../../../boards/evk1104; ../../../../../../../../../../utils; ../../../../../../../../../../drivers/gpio; ../../..; ../../../../../../../../../../drivers/spi; ../../../../../../../../../../utils/preprocessor; ../../../../../../../../../audio/audio_player/players/usb; ../../../enum/device; ../../../../../../../../../../../common/utils; ../../../../../../../../../../drivers/usbb/_asf_v1/enum; ..; ../../../../../../../../../../drivers/abdac; ../../../../..; ../../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../components/audio/amp/tpa6130a2; ../../../../../../../../../../drivers/usart; ../../../../../../../../../../drivers/flashc; ../../../enum; ../../../../../../../../../../drivers/intc; ../../../../../../../../../../drivers/ebi/smc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/debug
    ../../../../../../../../../../utils/debug/: print_funcs.c debug.c
  group avr32/utils/startup
    ../../../../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/drivers/pdca
    ../../../../../../../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usart
    ../../../../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/pm
    ../../../../../../../../../../drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/rtc
    ../../../../../../../../../../drivers/rtc/: rtc.c
  group avr32/drivers/abdac
    ../../../../../../../../../../drivers/abdac/: abdac.c
  group avr32/drivers/gpio
    ../../../../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/ebi/smc
    ../../../../../../../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/spi
    ../../../../../../../../../../drivers/spi/: spi.c
  group avr32/drivers/twim
    ../../../../../../../../../../drivers/twim/: twim.c
  group avr32/drivers/ssc/i2s
    ../../../../../../../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/services/usb/_asf_v1/class/audio/examples/device
    ../../../: audio_example.c device_hid_task.c avr32_logo.c microphone_samples.c device_audio_task.c
  group avr32/services/usb/_asf_v1/class/audio/examples/device/enum/device
    ../../../enum/device/: usb_specific_request.c usb_descriptors.c
  group avr32/services/usb/_asf_v1/class/audio/examples/device/user_interface/controller
    ../../../user_interface/controller/: qt60168_controller.c qt60168_controller_init.c
  group avr32/services/audio/audio_player/players/usb
    ../../../../../../../../../audio/audio_player/players/usb/: usb_stream_player.c
  group avr32/services/audio/audio_mixer
    ../../../../../../../../../audio/audio_mixer/: audio_mixer.c
  group avr32/boards/evk1104
    ../../../../../../../../../../boards/evk1104/: led.c
  group avr32/components/display/et024006dhu
    ../../../../../../../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/audio/amp/tpa6130a2
    ../../../../../../../../../../components/audio/amp/tpa6130a2/: tpa6130.c
  group avr32/components/touch/qt60168
    ../../../../../../../../../../components/touch/qt60168/: qt60168.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: read.c write.c
