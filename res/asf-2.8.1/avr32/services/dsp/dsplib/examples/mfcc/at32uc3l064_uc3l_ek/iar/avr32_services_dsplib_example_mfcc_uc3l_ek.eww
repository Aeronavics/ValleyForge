<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_dsplib_example_mfcc_uc3l_ek.ewp</path>
	</project>
</workspace>
