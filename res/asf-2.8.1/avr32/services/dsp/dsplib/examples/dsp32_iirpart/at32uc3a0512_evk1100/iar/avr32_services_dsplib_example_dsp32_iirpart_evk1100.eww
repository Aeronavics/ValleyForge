<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_dsplib_example_dsp32_iirpart_evk1100.ewp</path>
	</project>
</workspace>
