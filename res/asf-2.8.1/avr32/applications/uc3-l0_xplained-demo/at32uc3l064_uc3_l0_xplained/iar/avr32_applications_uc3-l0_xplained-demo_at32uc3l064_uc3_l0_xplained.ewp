# IAR project avr32_applications_uc3-l0_xplained-demo_at32uc3l064_uc3_l0_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/scif; ..; ../../../../boards; ../../../../drivers/pdca; ../../../../drivers/pm; ../..; ../../../../drivers/pwma; ../../../../utils/debug; ../../../../drivers/tc; ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/common; ../../../../utils; ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/include; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/flashcdw; ../../../../drivers/adcifb; ../../../../../common/boards; ../../../../drivers/usart; ../../../../../thirdparty/qtouch/qdebug; ../../../../utils/preprocessor; ../../../../boards/uc3_l0_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar
    ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar/: libuc3l-qtouch-iar.r82
  group thirdparty/qtouch/devspecific/uc3/uc3l0/common
    ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/common/: SERIAL.c
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebugTransport.c QDebug_at32uc3l.c
  group avr32/drivers/adcifb
    ../../../../drivers/adcifb/: adcifb.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/pwma
    ../../../../drivers/pwma/: pwma.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3l.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashcdw
    ../../../../drivers/flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/applications/uc3-l0_xplained-demo
    ../../: touch.c uc3-l0_xplained_demo.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3_l0_xplained
    ../../../../boards/uc3_l0_xplained/: led.c init.c
  group common/services/clock/uc3l
    ../../../../../common/services/clock/uc3l/: osc.c sysclk.c dfll.c
