<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-a3_avrsbin1-demo.ewp</path>
	</project>
</workspace>
