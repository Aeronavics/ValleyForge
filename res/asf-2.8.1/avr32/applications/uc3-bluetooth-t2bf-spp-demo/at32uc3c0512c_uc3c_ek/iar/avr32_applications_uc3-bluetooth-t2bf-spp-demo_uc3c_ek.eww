<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-bluetooth-t2bf-spp-demo_uc3c_ek.ewp</path>
	</project>
</workspace>
