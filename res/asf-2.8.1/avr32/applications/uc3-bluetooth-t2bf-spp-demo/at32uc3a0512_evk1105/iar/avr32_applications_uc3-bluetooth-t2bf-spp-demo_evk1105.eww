<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-bluetooth-t2bf-spp-demo_evk1105.ewp</path>
	</project>
</workspace>
