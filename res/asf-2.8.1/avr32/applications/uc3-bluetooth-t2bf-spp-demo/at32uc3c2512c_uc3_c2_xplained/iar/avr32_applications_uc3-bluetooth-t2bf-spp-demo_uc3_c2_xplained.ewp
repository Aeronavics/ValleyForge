# IAR project avr32_applications_uc3-bluetooth-t2bf-spp-demo_uc3_c2_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0xC0
  General.GCStackSize: 0x10
  General.GHeapSize: 0x462E
  ICCAVR32.CCDefines: BOARD=UC3_C2_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../common/services/usb/class/cdc/device; ../../../../drivers/scif; ../../../../../thirdparty/micrium/ucos-ii/uc-cpu; ../../../../boards; ../../conf; ../../../../drivers/usbc; ../../../../drivers/pm; ../../user_interface/gui; ..; ../../../../../common/utils/stdio/stdio_usb; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/cdc; ../../../../../common/services/clock; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/cpu/cycle_counter; ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar; ../../bsp; ../../user_interface/controller; ../../../../boards/uc3_c2_xplained; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../../thirdparty/cybercom/t2bf; ../../../../services/delay; ../../../../utils/preprocessor; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar; ../../../../drivers/intc; ../../../../drivers/tc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_C2_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3c2512_nvram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/cybercom/t2bf/iar
    ../../../../../thirdparty/cybercom/t2bf/iar/: tblue_lib.r82 t2bf_lib.r82
  group thirdparty/micrium/ucos-ii/ucos-ii/source
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source/: os_tmr.c os_sem.c os_mem.c os_time.c os_core.c os_q.c os_task.c os_flag.c os_mbox.c os_mutex.c
  group thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar/: cpu_a.asm
  group avr32/boards/uc3_c2_xplained
    ../../../../boards/uc3_c2_xplained/: led.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo
    ../../: appEngine_t2bf_atmel.c main.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/gui
    ../../user_interface/gui/: usart_gui.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/controller
    ../../user_interface/controller/: usart_controller.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/conf
    ../../conf/: uart_config.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/bsp
    ../../bsp/: bsp-c2-xplained.c vectors.asm
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/usbc
    ../../../../drivers/usbc/: usbc_device.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c
  group avr32/services/delay
    ../../../../services/delay/: delay.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: sysclk.c osc.c pll.c
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
