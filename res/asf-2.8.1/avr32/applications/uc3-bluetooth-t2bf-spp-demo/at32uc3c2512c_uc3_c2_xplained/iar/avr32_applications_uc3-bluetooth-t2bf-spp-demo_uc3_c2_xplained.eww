<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-bluetooth-t2bf-spp-demo_uc3_c2_xplained.ewp</path>
	</project>
</workspace>
