<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_evk1101-demo_example.ewp</path>
	</project>
</workspace>
