<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_evk1104-usb-msc-sd-demo_example.ewp</path>
	</project>
</workspace>
