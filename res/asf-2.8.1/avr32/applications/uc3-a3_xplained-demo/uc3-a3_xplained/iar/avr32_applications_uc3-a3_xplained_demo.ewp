# IAR project avr32_applications_uc3-a3_xplained_demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/gpio; ../../../../../common/services/clock; ../../../../utils/debug; ../../../../drivers/tc; ../..; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../boards; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../../../../common/utils; ../../../../utils/preprocessor; ../../../../drivers/pdca; ../../../../drivers/pm; ..; ../../qdebug; ../../../../drivers/spi; ../../../../boards/uc3_a3_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/uc3-a3_xplained-demo
    ../../: libuc3a-32qt-k-8rs.r82 touch.c uc3-a3_xplained_demo.c
  group avr32/applications/uc3-a3_xplained-demo/qdebug
    ../../qdebug/: QDebug.c QDebugTransport.c SPI_Master.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/boards/uc3_a3_xplained
    ../../../../boards/uc3_a3_xplained/: led.c init.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c
