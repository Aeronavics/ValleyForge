<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-a3_xplained_demo.ewp</path>
	</project>
</workspace>
