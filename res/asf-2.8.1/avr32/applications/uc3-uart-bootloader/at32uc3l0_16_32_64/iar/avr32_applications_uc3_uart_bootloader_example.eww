<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3_uart_bootloader_example.ewp</path>
	</project>
</workspace>
