# IAR project avr32_applications_uc3_uart_bootloader_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../boards/dummy; ../../../../utils/preprocessor; ../../../../../common/utils; ../../boot; ../../../../drivers/scif; ../../../../../common/boards; ../../../../drivers/usart; ../../../../boards; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../intc; ../../../../drivers/gpio; ../..; ../../../../drivers/pm; ../../../../drivers/flashcdw; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkat32uc3l-isp.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3l.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/flashcdw
    ../../../../drivers/flashcdw/: flashcdw.c
  group avr32/applications/uc3-uart-bootloader
    ../../: uart_dfu.c isp.c
  group avr32/applications/uc3-uart-bootloader/clocks
    ../../clocks/: conf_clocks.c
  group avr32/applications/uc3-uart-bootloader/intc
    ../../intc/: intc.c
  group avr32/applications/uc3-uart-bootloader/boot
    ../../boot/: boot.s82
