<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3_c2_xplained_demo_example.ewp</path>
	</project>
</workspace>
