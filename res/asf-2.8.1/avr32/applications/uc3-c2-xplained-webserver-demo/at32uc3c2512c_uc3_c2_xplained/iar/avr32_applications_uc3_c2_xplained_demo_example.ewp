# IAR project avr32_applications_uc3_c2_xplained_demo_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0xC0
  General.GCStackSize: 0x10
  General.GHeapSize: 0x9000
  ICCAVR32.CCDefines: HTTP_USED=1; FREERTOS_USED; BOARD=UC3_C2_XPLAINED; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../common/services/usb/class/cdc; ../../../../../common/services/usb/class/cdc/device; ../../network/basicweb; ../../../../drivers/scif; ../../../../../common/boards; ../../../../drivers/macb; ..; ../../../../boards; ../../../../drivers/usbc; ../../../../drivers/pm; ../../../../components/ethernet_phy/dp83848; ../../display; ../../conf; ../../../../drivers/tc; ../../../../components/ethernet_phy/rtl8201; ../../../../../common/utils/stdio/stdio_usb; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../network; ../../../../../thirdparty/freertos/source/include; ../../../../utils/preprocessor; ../../../../../common/services/clock; ../../../../../thirdparty/lwip/lwip-1.3.2/src/include/ipv4; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/cpu/cycle_counter; ../../../../boards/uc3_c2_xplained; ../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3; ../../../../components/ethernet_phy/dummy_phy; ../../../../components/ethernet_phy; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../../thirdparty/lwip/lwip-1.3.2/src/include; ../../../../services/delay; ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/include; ../../../../drivers/intc; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3c/2512c/iar/lnkuc3c2512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.3.2/src/core
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/core/: sys.c tcp.c tcp_in.c init.c memp.c mem.c dns.c tcp_out.c udp.c stats.c netif.c dhcp.c raw.c pbuf.c
  group thirdparty/lwip/lwip-1.3.2/src/core/ipv4
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/core/ipv4/: igmp.c icmp.c autoip.c inet.c ip.c inet_chksum.c ip_addr.c ip_frag.c
  group thirdparty/lwip/lwip-1.3.2/src/api
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/api/: netifapi.c sockets.c err.c netdb.c netbuf.c api_lib.c api_msg.c tcpip.c
  group thirdparty/lwip/lwip-1.3.2/src/netif
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/netif/: etharp.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3
    ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif
    ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/source
    ../../../../../thirdparty/freertos/source/: croutine.c list.c tasks.c queue.c timers.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../../thirdparty/freertos/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: port.c exception.s82
  group avr32/boards/uc3_c2_xplained
    ../../../../boards/uc3_c2_xplained/: led.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/macb
    ../../../../drivers/macb/: macb.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/usbc
    ../../../../drivers/usbc/: usbc_device.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c
  group avr32/services/delay
    ../../../../services/delay/: delay.c
  group avr32/applications/uc3-c2-xplained-webserver-demo
    ../../: main.c
  group avr32/applications/uc3-c2-xplained-webserver-demo/display
    ../../display/: display_usart.c displayTask.c
  group avr32/applications/uc3-c2-xplained-webserver-demo/network
    ../../network/: ethernet.c
  group avr32/applications/uc3-c2-xplained-webserver-demo/network/basicweb
    ../../network/basicweb/: BasicWEB.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: sysclk.c osc.c pll.c
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
