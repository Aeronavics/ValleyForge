<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_evk11xx-uc3b-usb-hid-qtouch-debug_example.ewp</path>
	</project>
</workspace>
