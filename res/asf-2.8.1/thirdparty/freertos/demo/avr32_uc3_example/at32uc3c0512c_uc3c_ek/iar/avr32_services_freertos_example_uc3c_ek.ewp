# IAR project avr32_services_freertos_example_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x0800
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xF300
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../source/include; ../../../../../../avr32/boards/uc3c_ek; ../../../../../../avr32/utils/preprocessor; ../../../common/include; ../../../../source/portable/iar/avr32_uc3; ../../../../../../avr32/drivers/scif; ../../../../../../avr32/drivers/tc; ../../../../../../common/boards; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ..; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../common/utils; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/freertos/source
    ../../../../source/: timers.c list.c tasks.c croutine.c queue.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../source/portable/iar/avr32_uc3/: write.c port.c read.c exception.s82
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: comtest.c BlockQ.c QPeek.c AltBlock.c countsem.c flash.c dynamic.c flop.c AltBlckQ.c recmutex.c crhook.c GenQTest.c semtest.c crflash.c death.c integer.c AltPollQ.c PollQ.c blocktim.c AltQTest.c
  group thirdparty/freertos/demo/avr32_uc3_example
    ../../: main.c
  group thirdparty/freertos/demo/avr32_uc3_example/serial
    ../../serial/: serial.c
  group thirdparty/freertos/demo/avr32_uc3_example/partest
    ../../partest/: ParTest.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/boards/uc3c_ek
    ../../../../../../avr32/boards/uc3c_ek/: led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
