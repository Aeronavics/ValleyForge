<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_freertos_example_uc3c_ek.ewp</path>
	</project>
</workspace>
