<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_freertos_example_evk1105.ewp</path>
	</project>
</workspace>
