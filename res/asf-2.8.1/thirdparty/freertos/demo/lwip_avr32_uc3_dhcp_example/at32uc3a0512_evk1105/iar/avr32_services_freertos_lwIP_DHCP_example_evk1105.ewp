# IAR project avr32_services_freertos_lwIP_DHCP_example_evk1105.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x9000
  ICCAVR32.CCDefines: SMTP_USED=0; HTTP_USED=1; FREERTOS_USED; TFTP_USED=1; BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../common/boards; ../../../../../../avr32/drivers/macb; ../../../lwip_avr32_uc3_example/network/basicsmtp; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/components/display/et024006dhu; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../lwip/lwip-1.3.2/src/include; ../../../../../../avr32/drivers/tc; ../../../../../../avr32/components/ethernet_phy/rtl8201; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../common/utils; ../..; ../../../../source/include; ../../../../../../avr32/utils/preprocessor; ../../../common/include; ../../../../../../common/services/clock; ../../../../../../avr32/drivers/pwm; ../../display; ..; ../../../../../lwip/lwip-1.3.2/src/include/ipv4; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../source/portable/iar/avr32_uc3; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../avr32/drivers/ebi/smc; ../../../../../../avr32/components/ethernet_phy; ../../../lwip_avr32_uc3_example/network; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/components/ethernet_phy/dp83848; ../../../../../../avr32/boards/evk1105; ../../../../../../avr32/services/delay; ../../../../../lwip/lwip-port-1.3.2/at32uc3/include; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/components/ethernet_phy/dummy_phy; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.3.2/src/core
    ../../../../../lwip/lwip-1.3.2/src/core/: netif.c tcp_in.c raw.c tcp.c pbuf.c udp.c tcp_out.c stats.c sys.c dhcp.c mem.c memp.c init.c dns.c
  group thirdparty/lwip/lwip-1.3.2/src/core/ipv4
    ../../../../../lwip/lwip-1.3.2/src/core/ipv4/: inet_chksum.c autoip.c ip_addr.c ip.c inet.c ip_frag.c igmp.c icmp.c
  group thirdparty/lwip/lwip-1.3.2/src/api
    ../../../../../lwip/lwip-1.3.2/src/api/: err.c netbuf.c netdb.c api_msg.c sockets.c api_lib.c netifapi.c tcpip.c
  group thirdparty/lwip/lwip-1.3.2/src/netif
    ../../../../../lwip/lwip-1.3.2/src/netif/: etharp.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3
    ../../../../../lwip/lwip-port-1.3.2/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif
    ../../../../../lwip/lwip-port-1.3.2/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/source
    ../../../../source/: timers.c tasks.c list.c croutine.c queue.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../source/portable/iar/avr32_uc3/: write.c port.c read.c exception.s82
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicsmtp
    ../../../lwip_avr32_uc3_example/network/basicsmtp/: BasicSMTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/partest
    ../../../lwip_avr32_uc3_example/partest/: ParTest.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example
    ../../: main.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/network
    ../../network/: ethernet.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/display
    ../../display/: display_et024006dhu.c displayTask.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group avr32/services/delay
    ../../../../../../avr32/services/delay/: delay.c
  group avr32/drivers/pwm
    ../../../../../../avr32/drivers/pwm/: pwm.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/macb
    ../../../../../../avr32/drivers/macb/: macb.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/ebi/smc
    ../../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: led.c
  group avr32/components/display/et024006dhu
    ../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c
