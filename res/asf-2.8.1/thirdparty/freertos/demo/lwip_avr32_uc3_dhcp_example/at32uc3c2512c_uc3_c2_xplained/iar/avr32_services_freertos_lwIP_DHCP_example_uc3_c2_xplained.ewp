# IAR project avr32_services_freertos_lwIP_DHCP_example_uc3_c2_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0xC0
  General.GCStackSize: 0x10
  General.GHeapSize: 0x9000
  ICCAVR32.CCDefines: SMTP_USED=0; BOARD=UC3_C2_XPLAINED; HTTP_USED=1; FREERTOS_USED; TFTP_USED=1; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ..; ../../../../../../avr32/drivers/scif; ../../../../../../common/boards; ../../../../../../avr32/drivers/macb; ../../../lwip_avr32_uc3_example/network/basicsmtp; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/usbc; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/flashc; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../lwip/lwip-1.3.2/src/include; ../../../../../../avr32/utils/debug; ../../../../../../avr32/drivers/tc; ../../../../../../avr32/components/ethernet_phy/rtl8201; ../../../../../../common/utils/stdio/stdio_usb; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../..; ../../../../../../common/services/usb/class/cdc; ../../../../source/include; ../../../../../lwip/lwip-port-1.3.2/at32uc3/include; ../../../common/include; ../../../../../../common/services/clock; ../../display; ../../../../../lwip/lwip-1.3.2/src/include/ipv4; ../../../../../../common/services/usb/udc; ../../../../../../common/services/usb; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/boards/uc3_c2_xplained; ../../../../source/portable/iar/avr32_uc3; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../avr32/components/ethernet_phy; ../../../lwip_avr32_uc3_example/network; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/components/ethernet_phy/dp83848; ../../../../../../avr32/services/delay; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/components/ethernet_phy/dummy_phy; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/2512c/iar/lnkuc3c2512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.3.2/src/core
    ../../../../../lwip/lwip-1.3.2/src/core/: netif.c tcp_in.c raw.c tcp.c pbuf.c udp.c tcp_out.c stats.c memp.c dhcp.c init.c sys.c mem.c dns.c
  group thirdparty/lwip/lwip-1.3.2/src/core/ipv4
    ../../../../../lwip/lwip-1.3.2/src/core/ipv4/: ip_addr.c autoip.c ip.c inet.c inet_chksum.c ip_frag.c igmp.c icmp.c
  group thirdparty/lwip/lwip-1.3.2/src/api
    ../../../../../lwip/lwip-1.3.2/src/api/: err.c netbuf.c sockets.c netdb.c netifapi.c api_lib.c api_msg.c tcpip.c
  group thirdparty/lwip/lwip-1.3.2/src/netif
    ../../../../../lwip/lwip-1.3.2/src/netif/: etharp.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3
    ../../../../../lwip/lwip-port-1.3.2/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif
    ../../../../../lwip/lwip-port-1.3.2/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/source
    ../../../../source/: timers.c queue.c tasks.c list.c croutine.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../source/portable/iar/avr32_uc3/: port.c exception.s82
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example
    ../../: main.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/display
    ../../display/: display_usart.c displayTask.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/network
    ../../network/: ethernet.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicsmtp
    ../../../lwip_avr32_uc3_example/network/basicsmtp/: BasicSMTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/partest
    ../../../lwip_avr32_uc3_example/partest/: ParTest.c
  group avr32/services/delay
    ../../../../../../avr32/services/delay/: delay.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/usbc
    ../../../../../../avr32/drivers/usbc/: usbc_device.c
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/macb
    ../../../../../../avr32/drivers/macb/: macb.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/utils/debug
    ../../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3_c2_xplained
    ../../../../../../avr32/boards/uc3_c2_xplained/: led.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common/services/clock/uc3c
    ../../../../../../common/services/clock/uc3c/: pll.c osc.c sysclk.c
