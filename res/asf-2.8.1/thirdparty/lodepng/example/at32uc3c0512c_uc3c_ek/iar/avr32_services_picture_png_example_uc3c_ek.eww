<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_picture_png_example_uc3c_ek.ewp</path>
	</project>
</workspace>
