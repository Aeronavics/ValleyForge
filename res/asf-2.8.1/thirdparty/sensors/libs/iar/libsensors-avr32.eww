<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libsensors-at32uc3a.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-at32uc3a3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-at32uc3b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-at32uc3c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-at32uc3l.ewp</path>
  </project>
  <batchBuild/>
</workspace>


