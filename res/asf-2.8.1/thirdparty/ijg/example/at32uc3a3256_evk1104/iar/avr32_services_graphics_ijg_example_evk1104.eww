<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_graphics_ijg_example_evk1104.ewp</path>
	</project>
</workspace>
