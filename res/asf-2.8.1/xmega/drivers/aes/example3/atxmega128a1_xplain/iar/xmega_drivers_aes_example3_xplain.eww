<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_aes_example3_xplain.ewp</path>
	</project>
</workspace>
