<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_aes_example1_xplain.ewp</path>
	</project>
</workspace>
