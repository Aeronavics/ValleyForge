<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_ioport_example_stk600-rc064x.ewp</path>
	</project>
</workspace>
