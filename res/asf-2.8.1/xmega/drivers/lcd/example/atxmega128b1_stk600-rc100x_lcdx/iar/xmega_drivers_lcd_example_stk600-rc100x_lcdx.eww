<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_lcd_example_stk600-rc100x_lcdx.ewp</path>
	</project>
</workspace>
