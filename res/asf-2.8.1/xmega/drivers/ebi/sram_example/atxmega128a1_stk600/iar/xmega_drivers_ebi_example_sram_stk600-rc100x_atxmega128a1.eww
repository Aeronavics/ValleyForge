<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_ebi_example_sram_stk600-rc100x_atxmega128a1.ewp</path>
	</project>
</workspace>
