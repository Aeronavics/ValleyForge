<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_ebi_unit_tests_sdram_xplain.ewp</path>
	</project>
</workspace>
