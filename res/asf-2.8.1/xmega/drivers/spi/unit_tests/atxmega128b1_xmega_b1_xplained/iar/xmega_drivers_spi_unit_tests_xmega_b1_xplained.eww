<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_spi_unit_tests_xmega_b1_xplained.ewp</path>
	</project>
</workspace>
