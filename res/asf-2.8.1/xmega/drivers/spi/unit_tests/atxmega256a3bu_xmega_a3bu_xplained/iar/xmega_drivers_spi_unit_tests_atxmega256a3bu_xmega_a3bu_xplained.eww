<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_spi_unit_tests_atxmega256a3bu_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
