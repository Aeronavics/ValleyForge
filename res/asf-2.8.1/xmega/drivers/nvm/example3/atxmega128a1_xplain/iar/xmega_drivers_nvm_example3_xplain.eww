<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_nvm_example3_xplain.ewp</path>
	</project>
</workspace>
