<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_dac_example2_xplain.ewp</path>
	</project>
</workspace>
