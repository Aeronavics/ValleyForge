# IAR project xmega_applications_xmega-a1_avrsbin1_visualizer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../common/utils/stdio/stdio_serial; ../../../../common/services; ../../../drivers/pmic; ../../../drivers/ioport; ../../../drivers/cpu; ../../../../common/services/serial; ../../../../common/boards; ../../../../common/services/twi; ../../../utils; ../../../boards/xmega_a1_xplained; ../../../../common/services/clock; ../../../utils/preprocessor; ../../../drivers/usart; ../../../../common/services/sensors; ../../../boards; ../../../../common/utils; ../conf; ../../../drivers/nvm; ../../../../common/services/sensors/module_config; ../../../../common/services/gpio; ../../../drivers/twi; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  XLINK.XclFile: lnk0t.xcl
  group thirdparty/sensors/libs/iar
    ../../../../thirdparty/sensors/libs/iar/: libsensors-atxmega128a1-debug.r90
  group xmega/drivers/nvm
    ../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/twi
    ../../../drivers/twi/: twim.c twis.c
  group xmega/drivers/usart
    ../../../drivers/usart/: usart.c
  group xmega/drivers/ioport
    ../../../drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../boards/xmega_a1_xplained/: init.c
  group common/services/sensors
    ../../../../common/services/sensors/: sensor_nvram.c sensor_platform.c sensor_bus.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/services/clock/xmega
    ../../../../common/services/clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../common/services/serial/: usart_serial.c
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
  group common/applications/sensors/inertial_visualizer
    ../../../../common/applications/sensors/inertial_visualizer/: main.c data_visualizer.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
