# IAR project xmega_application_xmega_b1_xplained_demo_xmega_b1_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: ACCESS_USB_ENABLED; BOARD=XMEGA_B1_XPLAINED; AT45DBX_ENABLE
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/services/usb/class/hid; ../../../../drivers/pmic; ../../../../drivers/ioport; ../../../../components/display/c42048a/c42048a_full_matrix0; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../utils; ../../../../../common/services/usb/class/msc; ../../../../../common/services/usb/class/hid/device/generic; ..; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/composite/device; ../../../../drivers/adc; ../../../../../common/services/usb/class/msc/device; ../../../../../common/services/clock; ../../../../boards/xmega_b1_xplained; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/tc; ../../../../boards; ../../../../../common/services/gpio; ../..; ../../../../../common/services/usb/class/hid/device; ../../../../drivers/usb; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/lcd; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: ACCESS_USB_ENABLED; BOARD=XMEGA_B1_XPLAINED; AT45DBX_ENABLE
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ACCESS_USB_ENABLED; BOARD=XMEGA_B1_XPLAINED; AT45DBX_ENABLE
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/usb/class/hid/device
    ../../../../../common/services/usb/class/hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../../../../../common/services/usb/class/hid/device/generic/: udi_hid_generic.c
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc.c
  group common/services/usb/class/composite/device
    ../../../../../common/services/usb/class/composite/device/: udi_composite_desc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group xmega/applications/xmega_b1_xplained_demo
    ../../: ui.c usb_hid_com.c adc_sensors.c main.c
  group xmega/drivers/lcd
    ../../../../drivers/lcd/: lcd.c
  group xmega/drivers/ioport
    ../../../../drivers/ioport/: ioport.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c
  group xmega/drivers/usb
    ../../../../drivers/usb/: usb_device.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../boards/xmega_b1_xplained/: init.c
  group xmega/components/display/c42048a/c42048a_full_matrix0
    ../../../../components/display/c42048a/c42048a_full_matrix0/: c42048a.c
