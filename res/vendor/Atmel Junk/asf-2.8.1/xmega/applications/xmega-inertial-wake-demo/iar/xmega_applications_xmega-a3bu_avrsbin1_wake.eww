<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a3bu_avrsbin1_wake.ewp</path>
	</project>
</workspace>
