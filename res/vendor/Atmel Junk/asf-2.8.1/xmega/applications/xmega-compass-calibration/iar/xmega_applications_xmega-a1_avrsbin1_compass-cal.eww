<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a1_avrsbin1_compass-cal.ewp</path>
	</project>
</workspace>
