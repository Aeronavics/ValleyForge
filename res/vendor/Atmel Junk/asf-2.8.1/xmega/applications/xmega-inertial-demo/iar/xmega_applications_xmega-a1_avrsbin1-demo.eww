<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a1_avrsbin1-demo.ewp</path>
	</project>
</workspace>
