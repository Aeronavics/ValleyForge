# IAR project xmega_application_xmega_b1_xplained_voltage_meter_xmega_b1_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../components/display/c42048a/c42048a_full_matrix0; ../../../../drivers/pmic; ../../../../drivers/ioport; ../../../../drivers/adc; ../../../../boards/xmega_b1_xplained; ../../../../../common/boards; ..; ../../../../drivers/tc; ../../../../utils; ../../../../../common/services/clock; ../../../../utils/preprocessor; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../boards; ../../../../drivers/lcd; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/nvm; ../..; ../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group xmega/applications/xmega_b1_xplained_voltage_meter
    ../../: ui.c main.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c
  group xmega/drivers/lcd
    ../../../../drivers/lcd/: lcd.c
  group xmega/drivers/ioport
    ../../../../drivers/ioport/: ioport.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../boards/xmega_b1_xplained/: init.c
  group xmega/components/display/c42048a/c42048a_full_matrix0
    ../../../../components/display/c42048a/c42048a_full_matrix0/: c42048a.c
