<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_application_xmega_b1_xplained_voltage_meter_xmega_b1_xplained.ewp</path>
	</project>
</workspace>
