<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_components_display_c42048a_example_stk600_rc100x_lcdx.ewp</path>
	</project>
</workspace>
