<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_usart_example_xplain.ewp</path>
	</project>
</workspace>
