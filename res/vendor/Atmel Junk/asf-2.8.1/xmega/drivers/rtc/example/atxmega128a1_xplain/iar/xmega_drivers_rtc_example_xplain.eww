<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_rtc_example_xplain.ewp</path>
	</project>
</workspace>
