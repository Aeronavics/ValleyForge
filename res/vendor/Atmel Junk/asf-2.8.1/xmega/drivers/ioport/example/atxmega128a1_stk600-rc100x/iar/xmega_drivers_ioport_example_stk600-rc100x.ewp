# IAR project xmega_drivers_ioport_example_stk600-rc100x.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC100X
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/stk600/rc100x; ../../..; ../../../../../../common/boards; ../../../../../utils; ..; ../../../../../utils/preprocessor; ../../../../../boards; ../../../../../../common/utils; ../../../../../../common/services/gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC100X
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X
  XLINK.XclFile: lnk0t.xcl
  group xmega/drivers/ioport
    ../../../: ioport.c
  group xmega/drivers/ioport/example
    ../../: ioport_example.c
  group xmega/boards/stk600/rc100x
    ../../../../../boards/stk600/rc100x/: init.c
