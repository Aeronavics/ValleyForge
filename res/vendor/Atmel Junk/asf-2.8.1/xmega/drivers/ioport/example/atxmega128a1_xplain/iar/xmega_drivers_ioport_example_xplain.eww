<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_ioport_example_xplain.ewp</path>
	</project>
</workspace>
