<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_tc_example3_xplain.ewp</path>
	</project>
</workspace>
