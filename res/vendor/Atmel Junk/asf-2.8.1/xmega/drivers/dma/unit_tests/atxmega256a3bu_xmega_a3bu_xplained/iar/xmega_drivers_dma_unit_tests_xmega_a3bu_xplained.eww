<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_dma_unit_tests_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
