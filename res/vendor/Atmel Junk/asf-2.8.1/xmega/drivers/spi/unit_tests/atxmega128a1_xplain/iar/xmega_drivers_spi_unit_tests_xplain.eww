<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_spi_unit_tests_xplain.ewp</path>
	</project>
</workspace>
