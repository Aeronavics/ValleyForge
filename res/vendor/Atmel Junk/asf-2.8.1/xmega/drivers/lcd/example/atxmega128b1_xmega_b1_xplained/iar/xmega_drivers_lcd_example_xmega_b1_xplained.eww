<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_lcd_example_xmega_b1_xplained.ewp</path>
	</project>
</workspace>
