<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_ebi_example_sdram_xplain.ewp</path>
	</project>
</workspace>
