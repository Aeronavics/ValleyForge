<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_polarssl_selftest_example_evk1100.ewp</path>
	</project>
</workspace>
