<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_polarssl_bench_example_evk1101.ewp</path>
	</project>
</workspace>
