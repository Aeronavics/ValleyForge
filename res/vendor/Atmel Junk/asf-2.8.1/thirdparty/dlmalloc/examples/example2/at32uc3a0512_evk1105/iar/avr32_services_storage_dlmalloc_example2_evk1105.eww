<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_storage_dlmalloc_example2_evk1105.ewp</path>
	</project>
</workspace>
