# IAR project avr32_services_storage_dlmalloc_example2_evk1105.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/boards/evk1105; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/utils/debug; ../../../../../newlib_addons/libs/include; ../../../../../../common/boards; ../../../../../../avr32/drivers/ebi/sdramc; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../common/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/drivers/pm; ../../conf; ../../../../../../avr32/components/memory/sdram; ../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/ebi/sdramc
    ../../../../../../avr32/drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/debug
    ../../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: led.c
  group thirdparty/dlmalloc
    ../../../../: dlmalloc.c dlsbrk.c
  group thirdparty/dlmalloc/portable/iar/avr32_uc3
    ../../../../portable/iar/avr32_uc3/: syscalls.c
  group thirdparty/dlmalloc/examples/example2
    ../../: main.c
