# IAR project avr32_services_freertos_example_uc3l-ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x0800
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3400
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../source/include; ../../../../../../avr32/utils/preprocessor; ../../../common/include; ../../../../source/portable/iar/avr32_uc3; ../../../../../../avr32/drivers/scif; ../../../../../../avr32/drivers/tc; ../../../../../../avr32/boards/uc3l_ek; ../../../../../../common/boards; ..; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../common/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/flashcdw; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/freertos/source
    ../../../../source/: timers.c tasks.c croutine.c list.c queue.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../source/portable/iar/avr32_uc3/: write.c port.c read.c exception.s82
  group thirdparty/freertos/demo/avr32_uc3_example
    ../../: main.c
  group thirdparty/freertos/demo/avr32_uc3_example/serial
    ../../serial/: serial.c
  group thirdparty/freertos/demo/avr32_uc3_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: BlockQ.c QPeek.c comtest.c AltBlock.c countsem.c flash.c dynamic.c flop.c recmutex.c crhook.c GenQTest.c semtest.c crflash.c death.c AltBlckQ.c integer.c AltPollQ.c PollQ.c blocktim.c AltQTest.c
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3l.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/boards/uc3l_ek
    ../../../../../../avr32/boards/uc3l_ek/: led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
