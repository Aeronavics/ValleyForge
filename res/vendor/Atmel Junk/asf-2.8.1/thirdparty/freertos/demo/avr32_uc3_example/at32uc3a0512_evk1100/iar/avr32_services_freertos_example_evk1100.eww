<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_freertos_example_evk1100.ewp</path>
	</project>
</workspace>
