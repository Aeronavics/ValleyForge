<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_freertos_lwIP_DHCP_example_uc3_c2_xplained.ewp</path>
	</project>
</workspace>
