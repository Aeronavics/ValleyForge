<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_graphics_ijg_example_evk1105.ewp</path>
	</project>
</workspace>
