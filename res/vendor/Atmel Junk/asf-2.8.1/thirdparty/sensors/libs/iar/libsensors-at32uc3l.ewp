# IAR project libsensors-at32uc3l.ewp, settings and files
configuration release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCDiagSuppress: Pe193, Pa050, Pa093, Pe188
  ICCAVR32.CCIncludePath2: ..\..\..\..\avr32\utils\; ..\..\..\..\avr32\utils\preprocessor\; ..\..\..\..\avr32\services\delay\; ..\..\..\..\avr32\drivers\gpio\; ..\..\..\..\avr32\drivers\intc\; ..\..\..\..\avr32\drivers\cpu\cycle_counter\; ..\..\..\..\avr32\drivers\flashc\; ..\..\..\..\avr32\drivers\flashcdw\; ..\..\..\..\common\interrupt; ..\..\..\..\common\utils; ..\..\..\..\common\services
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 0
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: ..\..\..\..\avr32\utils\; ..\..\..\..\avr32\utils\preprocessor\; ..\..\..\..\common\utils
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration debug (AVR32, debug)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\..\..\avr32\utils\; ..\..\..\..\common\utils; ..\..\..\..\avr32\utils\preprocessor\
  group driver
    ../../../../common/services/sensors/drivers/akm/: ak8975.c
    ../../../../common/services/sensors/drivers/bosch/: bma020.c bma150.c bma180.c bmp.c
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c
    ../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c
    ../../../../common/services/sensors/: sensor.c
