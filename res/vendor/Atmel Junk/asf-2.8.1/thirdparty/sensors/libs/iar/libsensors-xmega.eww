<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libsensors-atxmega32a4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega32a4u.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega128a1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega256a3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega256a3u.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega256a3b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libsensors-atxmega256a3bu.ewp</path>
  </project>
  <batchBuild/>
</workspace>


