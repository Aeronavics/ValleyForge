<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_dataflash_at45dbx_example_uc3l_ek.ewp</path>
	</project>
</workspace>
