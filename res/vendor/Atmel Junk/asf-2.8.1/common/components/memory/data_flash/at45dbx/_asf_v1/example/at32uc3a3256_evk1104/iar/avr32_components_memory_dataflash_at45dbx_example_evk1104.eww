<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_dataflash_at45dbx_example_evk1104.ewp</path>
	</project>
</workspace>
