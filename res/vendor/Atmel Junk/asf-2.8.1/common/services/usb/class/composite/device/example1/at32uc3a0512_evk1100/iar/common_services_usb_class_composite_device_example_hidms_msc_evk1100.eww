<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_composite_device_example_hidms_msc_evk1100.ewp</path>
	</project>
</workspace>
