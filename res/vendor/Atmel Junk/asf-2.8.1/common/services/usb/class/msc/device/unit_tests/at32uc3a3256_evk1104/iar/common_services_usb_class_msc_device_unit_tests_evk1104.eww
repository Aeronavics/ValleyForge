<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_unit_tests_evk1104.ewp</path>
	</project>
</workspace>
