<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_unit_tests_uc3c_ek.ewp</path>
	</project>
</workspace>
