# IAR project common_services_usb_class_hid_device_mouse_example_atxmega256a3bu_xmega_a3bu_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../../xmega/drivers/ioport; ../../../..; ../../../../../../../../clock; ../../../../../../../../../boards; ../../../../../../../../../../xmega/drivers/nvm; ..; ../../../../../../../../../../xmega/utils/preprocessor; ../..; ../../../../../../../../../../xmega/utils; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../gpio; ../../../../../../../../../utils; ../../../../../../../../../../xmega/boards; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c
  group common/services/usb/class/hid/device/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/device/mouse/example/atxmega256a3bu_xmega_a3bu_xplained
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/ioport
    ../../../../../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
