<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_device_mouse_unit_tests_evk1105.ewp</path>
	</project>
</workspace>
