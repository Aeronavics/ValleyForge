<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_cdc_device_unit_tests_xmega_b1_xplained.ewp</path>
	</project>
</workspace>
