# IAR project common_services_usb_class_hid_device_mouse_unit_tests_xmega_b1_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../../xmega/drivers/pmic; ../..; ../../../../../../../../../../xmega/drivers/ioport; ..; ../../../../../../../../../../xmega/utils; ../../../../../../../../serial; ../../../../../../../../../../xmega/drivers/usart; ../../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../..; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../clock; ../../../../../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../xmega/boards; ../../../../../../../../gpio; ../../../..; ../../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../boards; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../..; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c
  group xmega/drivers/usart
    ../../../../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/ioport
    ../../../../../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../../../../../../../xmega/boards/xmega_b1_xplained/: init.c
