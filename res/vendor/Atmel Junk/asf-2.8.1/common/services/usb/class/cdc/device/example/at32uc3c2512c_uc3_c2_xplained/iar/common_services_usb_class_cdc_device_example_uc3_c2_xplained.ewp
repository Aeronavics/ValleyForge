# IAR project common_services_usb_class_cdc_device_example_uc3_c2_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_C2_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../..; ../../../../../../../../../avr32/boards/uc3_c2_xplained; ../../..; ../../../../../../../../../avr32/drivers/usbc; ../../../../../../../clock; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../boards; ../../../../../..; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../udc; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/utils/preprocessor; ../..; ../../../../../../../sleepmgr; ../../../../../../../../utils; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_C2_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/2512c/iar/lnkuc3c2512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/class/cdc/device/example
    ../../: uart_uc3.c main.c
  group common/services/usb/class/cdc/device/example/at32uc3c2512c_uc3_c2_xplained
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/clock/uc3c
    ../../../../../../../clock/uc3c/: pll.c sysclk.c osc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/usbc
    ../../../../../../../../../avr32/drivers/usbc/: usbc_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/uc3_c2_xplained
    ../../../../../../../../../avr32/boards/uc3_c2_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
