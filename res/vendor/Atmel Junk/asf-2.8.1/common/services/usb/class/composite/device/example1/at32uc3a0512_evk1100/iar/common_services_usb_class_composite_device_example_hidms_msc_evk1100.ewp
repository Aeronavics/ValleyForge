# IAR project common_services_usb_class_composite_device_example_hidms_msc_evk1100.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: ACCESS_USB_ENABLED; VIRTUAL_MEMORY_ENABLE; BOARD=EVK1100; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/components/joystick/skrhabe010; ../..; ../../../../../../../../../avr32/boards; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/eic; ../../../../../../../../components/memory/virtual_mem; ..; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1100; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../../../avr32/drivers/spi; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../hid/device; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../msc; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c
  group common/services/usb/class/composite/device/example1
    ../../: main.c
  group common/services/usb/class/composite/device/example1/at32uc3a0512_evk1100
    ../: ui.c
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a0_a1
    ../../../../../../../clock/uc3a0_a1/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group avr32/boards/evk1100
    ../../../../../../../../../avr32/boards/evk1100/: led.c init.c
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
