<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_unit_tests_stk600_atxmega128a4u.ewp</path>
	</project>
</workspace>
