# IAR project common_services_usb_class_dfu_atmel_device_bootloader_atxmega16a4u.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm16a4u ATxmega16A4U
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../../xmega/boards; ../../../../../../../udc; ../../../../../../../../../../xmega/drivers/usb; ../..; ../../../../../../../../../../xmega/drivers/nvm; ../../conf; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../boards; ../../../../../../../../../../xmega/utils; ../../../../../../../../clock; ../../../../../../..; .; ../../../..; ../../../../../../../../isp/flip; ../../../../../../../../../utils; ../../../../../../../../../../xmega/drivers/cpu; ../../../../..; ../../../../../../../../../../xmega/boards/dummy; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD
  XLINK.XclFile: atxmega16a4u_boot.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  group common/services/usb/udc
    ../../../../../../../udc/: udc_dfu_small.c
  group common/services/usb/class/dfu_flip/device
    ../../../../: udi_dfu_atmel_desc.c udi_dfu_atmel.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega
    ../../: sysclk_opt.c main.c
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c
  group common/services/isp/flip/xmega
    ../../../../../../../../isp/flip/xmega/: isp.c cstartup.s90
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s
