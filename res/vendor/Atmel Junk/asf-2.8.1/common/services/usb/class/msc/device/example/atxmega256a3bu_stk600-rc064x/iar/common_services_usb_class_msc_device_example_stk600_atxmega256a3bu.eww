<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_msc_device_example_stk600_atxmega256a3bu.ewp</path>
	</project>
</workspace>
