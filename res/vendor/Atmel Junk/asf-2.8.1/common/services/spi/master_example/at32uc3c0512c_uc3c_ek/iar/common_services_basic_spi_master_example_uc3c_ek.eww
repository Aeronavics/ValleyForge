<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_spi_master_example_uc3c_ek.ewp</path>
	</project>
</workspace>
