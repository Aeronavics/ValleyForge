# IAR project common_services_basic_spi_master_example_uc3l_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/drivers/gpio; ../../../../clock; ../../../../../boards; ../../..; ../../../../../../avr32/boards/uc3l_ek; ../../../uc3_spi; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/flashcdw; ../../../../../utils; ..; ../../../../../../avr32/drivers/spi; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c
  group common/services/spi/uc3_spi
    ../../../uc3_spi/: spi_master.c
  group common/services/spi/master_example
    ../../: spi_master_example.c
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/uc3l_ek
    ../../../../../../avr32/boards/uc3l_ek/: init.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
