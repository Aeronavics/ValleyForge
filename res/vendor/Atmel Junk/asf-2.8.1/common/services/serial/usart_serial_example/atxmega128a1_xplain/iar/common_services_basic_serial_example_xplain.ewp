# IAR project common_services_basic_serial_example_xplain.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/ioport; ../../../../../../xmega/drivers/pmic; ..; ../../../../../../xmega/drivers/cpu; ../../..; ../../../../../boards; ../../../../../../xmega/utils; ../../../../clock; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../utils; ../..; ../../../../gpio; ../../../../../../xmega/boards/xplain; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN
  XLINK.XclFile: lnk0t.xcl
  group common/services/serial
    ../../../: usart_serial.c
  group common/services/serial/usart_serial_example
    ../../: usart_serial_example.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/ioport
    ../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
