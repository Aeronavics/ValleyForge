# IAR project common_services_basic_twi_master_example_stk600.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC100X
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/boards/stk600/rc100x; ../../../../../../xmega/drivers/twi; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../../boards; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/ioport; ../../../../../../xmega/utils/preprocessor; ../../../../gpio; ../..; ../../../../../../xmega/boards; ../../../../../utils; ../../..; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC100X
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X
  XLINK.XclFile: lnk0t.xcl
  group xmega/drivers/ioport
    ../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twim.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/stk600/rc100x
    ../../../../../../xmega/boards/stk600/rc100x/: init.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/twi/master_example
    ../../: twi_master_example.c
