<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_twi_master_example_evk1101.ewp</path>
	</project>
</workspace>
