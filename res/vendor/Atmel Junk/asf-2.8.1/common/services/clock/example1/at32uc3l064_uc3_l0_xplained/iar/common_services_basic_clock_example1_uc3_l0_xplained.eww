<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example1_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
