<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example3_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
