<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_evk1100.ewp</path>
	</project>
</workspace>
