<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
