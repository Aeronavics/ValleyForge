<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_evk1101.ewp</path>
	</project>
</workspace>
