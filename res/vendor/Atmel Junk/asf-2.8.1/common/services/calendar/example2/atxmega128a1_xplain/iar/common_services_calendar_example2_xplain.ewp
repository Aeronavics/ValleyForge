# IAR project common_services_calendar_example2_xplain.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../clock; ../../../../gpio; ../../../../../boards; ..; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/ioport; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/boards; ../..; ../../../../../utils; ../../../../../../xmega/boards/xplain; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN
  XLINK.XclFile: lnk0t.xcl
  group xmega/drivers/ioport
    ../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
  group common/services/calendar
    ../../../: calendar.c
  group common/services/calendar/example2
    ../../: example2.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
