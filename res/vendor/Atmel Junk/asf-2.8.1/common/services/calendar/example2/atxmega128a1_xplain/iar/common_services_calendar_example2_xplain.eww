<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_calendar_example2_xplain.ewp</path>
	</project>
</workspace>
