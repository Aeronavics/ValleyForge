<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_calendar_unit_tests_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
