<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_gfx_mono_unit_tests_spinctrl_xplain.ewp</path>
	</project>
</workspace>
