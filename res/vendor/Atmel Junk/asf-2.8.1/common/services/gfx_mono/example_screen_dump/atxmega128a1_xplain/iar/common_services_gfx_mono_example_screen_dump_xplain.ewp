# IAR project common_services_gfx_mono_example_screen_dump_xplain.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN; GFX_MONO_C12832_A1Z=1
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../spi; ../../../../serial; ../../../../../boards; ../../../../../../xmega/utils; ../../..; ../../../../../../xmega/drivers/ioport; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../utils; ..; ../../../../../../xmega/boards/xplain; ../../../../gpio; ../../../../../components/display/st7565r; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN; GFX_MONO_C12832_A1Z=1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN; GFX_MONO_C12832_A1Z=1
  XLINK.XclFile: lnk0t.xcl
  group common/services/gfx_mono
    ../../../: gfx_mono_framebuffer.c gfx_mono_generic.c gfx_mono_c12832_a1z.c
  group common/services/gfx_mono/example_screen_dump
    ../../: example_screen_dump.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/components/display/st7565r
    ../../../../../components/display/st7565r/: st7565r.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/ioport
    ../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
