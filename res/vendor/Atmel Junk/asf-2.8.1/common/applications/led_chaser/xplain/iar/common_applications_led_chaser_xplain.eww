<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_applications_led_chaser_xplain.ewp</path>
	</project>
</workspace>
