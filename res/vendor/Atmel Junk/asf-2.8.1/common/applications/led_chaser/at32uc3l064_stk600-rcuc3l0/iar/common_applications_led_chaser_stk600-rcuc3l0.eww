<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_applications_led_chaser_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
