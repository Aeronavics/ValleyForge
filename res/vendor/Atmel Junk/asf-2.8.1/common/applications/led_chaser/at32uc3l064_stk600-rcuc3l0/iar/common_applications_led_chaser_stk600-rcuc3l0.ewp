# IAR project common_applications_led_chaser_stk600-rcuc3l0.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/scif; ../../../../boards; ../../../../services/clock; ../../../../../avr32/boards; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../utils; ../../../../../avr32/drivers/pm; ../../../../../avr32/drivers/flashcdw; ../../../../../avr32/boards/stk600/rcuc3l0; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3l
    ../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c
  group common/applications/led_chaser
    ../../: led_example.c
  group avr32/boards/stk600/rcuc3l0
    ../../../../../avr32/boards/stk600/rcuc3l0/: init.c
  group avr32/drivers/scif
    ../../../../../avr32/drivers/scif/: scif_uc3l.c
  group avr32/drivers/flashcdw
    ../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82
