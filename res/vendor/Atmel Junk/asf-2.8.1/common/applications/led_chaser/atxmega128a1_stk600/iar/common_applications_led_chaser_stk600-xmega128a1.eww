<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_applications_led_chaser_stk600-xmega128a1.ewp</path>
	</project>
</workspace>
