# IAR project avr32_applications_uc3_dsplib_demo_evk1104.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/ssc/i2s; ../../../../boards; ../../../../drivers/pdca; ../../../../components/audio; ../../../../drivers/twim; ../../../../drivers/pm; ../../../../utils/libs/dsplib/include; ../../../../components/touch/qt60168; ../../../../components/display/et024006dhu; ../../../../utils/debug; ../../../../boards/evk1104; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../conf; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/abdac; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../../../components/audio/amp/tpa6130a2; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../services/delay; ../../../../utils/preprocessor; ../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/libs/dsplib/at32ucr2/iar
    ../../../../utils/libs/dsplib/at32ucr2/iar/: libdsp-at32ucr2-dspspeed_opt.r82
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group avr32/components/audio/amp/tpa6130a2
    ../../../../components/audio/amp/tpa6130a2/: tpa6130.c
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/touch/qt60168
    ../../../../components/touch/qt60168/: qt60168.c
  group avr32/drivers/ssc/i2s
    ../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/abdac
    ../../../../drivers/abdac/: abdac.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/twim
    ../../../../drivers/twim/: twim.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/applications/uc3-dsplib-demo
    ../../: gui.c dsp_process.c background_image.c dsp_sprintf.c controller_evk1104.c demo.c
  group avr32/services/delay
    ../../../../services/delay/: delay.c
