# IAR project avr32_applications_uc3c-fpu-demo_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../components/display/et024006dhu; ../../../../utils/preprocessor; ../../../../boards/uc3c_ek; ../../../../drivers/scif; ../../conf; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../..; ../../../../drivers/flashc; ../../../../boards; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../../../services/delay; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/pm; ../../../../drivers/intc; ../../../../drivers/usart; ../../../../drivers/tc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3c.c
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/services/delay
    ../../../../services/delay/: delay.c
  group avr32/applications/uc3c-fpu-fractal-demo
    ../../: main.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
