# IAR project avr32_applications_uc3-bluetooth-t2bf-spp-demo_evk1104.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0xC0
  General.GCStackSize: 0x10
  General.GHeapSize: 0x462E
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../thirdparty/micrium/ucos-ii/uc-cpu; ../../../../drivers/rtc; ../../../../boards; ../../conf; ../../../../drivers/pm; ../../../../components/touch/qt60168; ../../../../components/display/et024006dhu; ../../../../utils/debug; ../../../../drivers/tc; ../../../../boards/evk1104; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../../../../common/services/clock; ../../user_interface/gui; ../../../../drivers/cpu/cycle_counter; ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar; ../../bsp; ../../user_interface/controller; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../../thirdparty/cybercom/t2bf; ../../../../services/delay; ../../../../utils/preprocessor; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar; ../../../../drivers/intc; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3a3256_nvram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/cybercom/t2bf/iar
    ../../../../../thirdparty/cybercom/t2bf/iar/: tblue_lib.r82 t2bf_lib.r82
  group thirdparty/micrium/ucos-ii/ucos-ii/source
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source/: os_tmr.c os_sem.c os_mem.c os_time.c os_core.c os_q.c os_task.c os_flag.c os_mbox.c os_mutex.c
  group thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar/: cpu_a.asm
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/touch/qt60168
    ../../../../components/touch/qt60168/: qt60168.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo
    ../../: appEngine_t2bf_atmel.c main.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/gui
    ../../user_interface/gui/: et024006dhu_gui.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/controller
    ../../user_interface/controller/: qt60168_controller.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/conf
    ../../conf/: uart_config.c
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/bsp
    ../../bsp/: bsp-evk1104.c vectors.asm
  group avr32/boards/evk1104
    ../../../../boards/evk1104/: led.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/rtc
    ../../../../drivers/rtc/: rtc.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/delay
    ../../../../services/delay/: delay.c
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c
