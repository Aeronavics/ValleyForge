<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-l0_avrsbin1-demo.ewp</path>
	</project>
</workspace>
