# IAR project avr32_applications_evk11xx-uc3b-usb-hid-qtouch-debug_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x4D00
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils; ../../../../services/usb/_asf_v1; ../../../../utils/preprocessor; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../drivers/usbb/_asf_v1; ../../../../../thirdparty/newlib_addons/libs/include; ../..; ../../../../../common/boards; ../../../../services/usb/_asf_v1/class/hid; ../../../../drivers/usart; ../../../../drivers/flashc; ../../conf; ../../../../drivers/pdca; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/gpio; ../../../../../common/services/fifo; ../../../../drivers/pm; ../../../../../common/utils; ../../enum/device; ../../../../drivers/intc; ../../../../drivers/usbb/_asf_v1/enum; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3b/1256/iar/lnkuc3b1256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug
    ../../: qtouch_debug_frame.c led.c device_hid_qtouch_debug_task.c hid_qtouch_debug.c
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug/enum/device
    ../../enum/device/: usb_specific_request.c usb_descriptors.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c
