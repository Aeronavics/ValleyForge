# IAR project avr32_applications_evk11xx-uc3b-virtual-com-port_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x3D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3D00
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../common/utils; ../../../../services/usb/_asf_v1; ../../../../utils/preprocessor; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../drivers/usbb/_asf_v1; ../../../../utils/debug; ../..; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../drivers/pm; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../conf; ../../../../drivers/gpio; ../../../../../common/services/fifo; ../../../../drivers/usbb/_asf_v1/enum; ../../../../drivers/intc; ../../../../services/usb/_asf_v1/class/cdc; ../../enum/device; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3b/1256/iar/lnkuc3b1256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/applications/evk11xx-uc3b-virtual-com-port
    ../../: uart_usb_lib.c main.c device_cdc_task.c
  group avr32/applications/evk11xx-uc3b-virtual-com-port/enum/device
    ../../enum/device/: usb_descriptors.c usb_specific_request.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c
