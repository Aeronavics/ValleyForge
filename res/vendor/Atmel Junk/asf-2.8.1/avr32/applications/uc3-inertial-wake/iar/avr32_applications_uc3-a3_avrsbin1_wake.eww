<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-a3_avrsbin1_wake.ewp</path>
	</project>
</workspace>
