# IAR project avr32_applications_scope-meter-and-filtering-demo_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/twim; ../../../../drivers/scif; ../../../../boards; ../../../../drivers/pevc; ../../../../components/touch/at42qt1060; ../../../../drivers/pm; ../../../../utils/libs/dsplib/include; ../../../../components/display/et024006dhu; ../../../../boards/uc3c_ek; ../../../../utils/debug; ../../../../drivers/tc; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/adcifa; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../conf; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../drivers/pdca; ../../../../services/delay; ../../../../utils/preprocessor; ../../../../drivers/dacifb; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/libs/dsplib/at32ucr3fp/iar
    ../../../../utils/libs/dsplib/at32ucr3fp/iar/: libdsp-at32ucr3fp-dspspeed_opt.r82
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/touch/at42qt1060
    ../../../../components/touch/at42qt1060/: at42qt1060.c
  group avr32/boards/uc3c_ek
    ../../../../boards/uc3c_ek/: init.c
  group avr32/drivers/adcifa
    ../../../../drivers/adcifa/: adcifa.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/pevc
    ../../../../drivers/pevc/: pevc.c
  group avr32/drivers/dacifb
    ../../../../drivers/dacifb/: dacifb.c
  group avr32/drivers/twim
    ../../../../drivers/twim/: twim.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/applications/uc3c-scope-meter-and-filtering
    ../../: gui.c controller.c adc_task.c noise_task.c sinus.c background_image.c dac_task.c filter_task.c remote_task.c main.c
  group avr32/services/delay
    ../../../../services/delay/: delay.c
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: osc.c pll.c sysclk.c
