<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_demo_evk1100_example_evk1100.ewp</path>
	</project>
</workspace>
