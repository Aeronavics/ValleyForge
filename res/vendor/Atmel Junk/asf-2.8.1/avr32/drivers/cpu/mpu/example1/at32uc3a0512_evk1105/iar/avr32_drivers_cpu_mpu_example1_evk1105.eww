<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_cpu_mpu_example1_evk1105.ewp</path>
	</project>
</workspace>
