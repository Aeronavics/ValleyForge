<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_pwma_example_uc3_l0_xplained.ewp</path>
	</project>
</workspace>
