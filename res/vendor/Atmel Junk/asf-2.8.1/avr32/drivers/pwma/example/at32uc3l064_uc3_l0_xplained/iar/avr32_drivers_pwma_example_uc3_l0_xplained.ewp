# IAR project avr32_drivers_pwma_example_uc3_l0_xplained.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../gpio; ../../../../scif; ../../../../../boards/uc3_l0_xplained; ../../../../../../common/boards; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../../services/delay; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../pm; ../../../../flashcdw; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/flashcdw
    ../../../../flashcdw/: flashcdw.c
  group avr32/drivers/pwma
    ../../../: pwma.c
  group avr32/drivers/pwma/example
    ../../: pwma_example.c
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3l.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../boards/uc3_l0_xplained/: led.c init.c
  group avr32/services/delay
    ../../../../../services/delay/: delay.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3l
    ../../../../../../common/services/clock/uc3l/: osc.c dfll.c sysclk.c
