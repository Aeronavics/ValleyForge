<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_pevc_example2_uc3c_ek.ewp</path>
	</project>
</workspace>
