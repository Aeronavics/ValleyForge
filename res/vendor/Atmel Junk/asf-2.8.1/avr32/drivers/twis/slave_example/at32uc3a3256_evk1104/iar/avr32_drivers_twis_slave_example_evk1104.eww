<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_twis_slave_example_evk1104.ewp</path>
	</project>
</workspace>
