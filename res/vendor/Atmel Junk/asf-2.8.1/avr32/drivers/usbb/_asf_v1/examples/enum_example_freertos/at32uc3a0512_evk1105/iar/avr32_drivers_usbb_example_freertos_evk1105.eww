<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_usbb_example_freertos_evk1105.ewp</path>
	</project>
</workspace>
