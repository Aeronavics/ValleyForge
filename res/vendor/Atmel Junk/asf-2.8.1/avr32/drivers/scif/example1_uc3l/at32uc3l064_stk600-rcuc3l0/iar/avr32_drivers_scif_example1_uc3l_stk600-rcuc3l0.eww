<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_scif_example1_uc3l_stk600-rcuc3l0.ewp</path>
	</project>
</workspace>
