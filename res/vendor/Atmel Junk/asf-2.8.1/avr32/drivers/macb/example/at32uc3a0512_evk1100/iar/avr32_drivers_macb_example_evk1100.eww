<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_macb_example_evk1100.ewp</path>
	</project>
</workspace>
