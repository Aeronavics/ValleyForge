<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_macb_example_uc3_c2_xplained.ewp</path>
	</project>
</workspace>
