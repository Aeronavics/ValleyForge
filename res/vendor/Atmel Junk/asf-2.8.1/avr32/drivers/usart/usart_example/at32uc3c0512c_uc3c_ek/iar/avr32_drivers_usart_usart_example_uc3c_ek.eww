<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_usart_usart_example_uc3c_ek.ewp</path>
	</project>
</workspace>
