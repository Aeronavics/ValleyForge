<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_twi_slave_example_evk1101.ewp</path>
	</project>
</workspace>
