<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_flashcdw_example_uc3l_ek.ewp</path>
	</project>
</workspace>
