<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example4_uc3l_ek.ewp</path>
	</project>
</workspace>
