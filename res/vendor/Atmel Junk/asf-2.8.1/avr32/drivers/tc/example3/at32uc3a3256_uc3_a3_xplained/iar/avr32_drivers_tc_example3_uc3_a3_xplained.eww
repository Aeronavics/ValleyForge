<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_tc_example3_uc3_a3_xplained.ewp</path>
	</project>
</workspace>
