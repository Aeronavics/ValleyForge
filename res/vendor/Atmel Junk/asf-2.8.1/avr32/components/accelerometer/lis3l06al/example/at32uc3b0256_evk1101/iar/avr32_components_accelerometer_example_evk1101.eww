<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_accelerometer_example_evk1101.ewp</path>
	</project>
</workspace>
