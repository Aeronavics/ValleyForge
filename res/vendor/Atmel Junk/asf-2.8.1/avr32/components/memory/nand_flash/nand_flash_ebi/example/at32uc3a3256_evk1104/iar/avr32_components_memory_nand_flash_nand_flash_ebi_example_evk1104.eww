<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_nand_flash_nand_flash_ebi_example_evk1104.ewp</path>
	</project>
</workspace>
