<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_sdmmc_mci_example_evk1104.ewp</path>
	</project>
</workspace>
