<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_components_memory_sdmmc_spi_unit_tests_evk1101.ewp</path>
	</project>
</workspace>
