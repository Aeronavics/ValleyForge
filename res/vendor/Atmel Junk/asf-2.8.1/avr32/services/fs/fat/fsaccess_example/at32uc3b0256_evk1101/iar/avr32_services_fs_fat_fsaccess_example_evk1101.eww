<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_fs_fat_fsaccess_example_evk1101.ewp</path>
	</project>
</workspace>
