<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_dsplib_example_benchmark_evk1100.ewp</path>
	</project>
</workspace>
