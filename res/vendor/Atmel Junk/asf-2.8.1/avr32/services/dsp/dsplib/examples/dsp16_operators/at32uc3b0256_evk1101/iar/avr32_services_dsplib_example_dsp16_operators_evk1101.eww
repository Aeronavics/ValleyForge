<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_dsplib_example_dsp16_operators_evk1101.ewp</path>
	</project>
</workspace>
