<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_dsplib_example_adpcm_wav_player_evk1100.ewp</path>
	</project>
</workspace>
