# IAR project avr32_services_usb_hid_generic_example_evk1101_asfv1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x3D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3D00
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../..; ../../../../../../../../../components/joystick/skrhabe010; ../../..; ../../../../../../../../../drivers/pm; ../../../conf; ../../../../../..; ../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../utils/debug; ../../../../../../../../../utils; ../../../../../../../../../boards/evk1101; ../../../../../../../../../drivers/gpio; ../../../../../../../../../../common/utils; ../../../enum/device; ../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../common/boards; ../../../../../../../../../boards; ../../../../../../../../../drivers/usart; ../../../../../../../../../drivers/flashc; ../../../../../../../../../utils/preprocessor; ../../../../../../../../../drivers/intc; ../../../enum; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_standard_request.c usb_device_task.c
  group avr32/drivers/pm
    ../../../../../../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/boards/evk1101
    ../../../../../../../../../boards/evk1101/: led.c
  group avr32/utils/debug
    ../../../../../../../../../utils/debug/: debug.c print_funcs.c
  group avr32/utils/startup
    ../../../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/usb/_asf_v1/class/hid/generic_examples
    ../../../: hid_generic_example.c device_generic_hid_task.c
  group avr32/services/usb/_asf_v1/class/hid/generic_examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: write.c read.c
