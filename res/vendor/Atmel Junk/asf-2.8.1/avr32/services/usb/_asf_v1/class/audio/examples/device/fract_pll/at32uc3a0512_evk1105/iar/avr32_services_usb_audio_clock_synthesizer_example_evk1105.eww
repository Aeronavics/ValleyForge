<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_usb_audio_clock_synthesizer_example_evk1105.ewp</path>
	</project>
</workspace>
