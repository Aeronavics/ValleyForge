# IAR project avr32_services_usb_cdc_example_evk1105_asfv1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x4000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x6000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../../../../../../../components/joystick/skrhabe010; ../../../../../../../../../boards; ../../../../../../../../../drivers/pm; ../../..; ../../../../../..; ../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../utils/debug; ../../../../../../../../../boards/evk1105; ../../../../../../../../../utils; ../../../../../../../../../drivers/gpio; ../../../../../../../../../components/touch/qt1081; ../../../../../../../../../../common/utils; ../../../conf; ../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../common/services/fifo; ../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../../../../../../../drivers/usbb/_asf_v1/enum/host; ../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../common/boards; ../../../enum; ../../../../../../../../../drivers/usart; ../../../../../../../../../drivers/flashc; ../../../../../../../../../utils/preprocessor; ../../../../../../../../../drivers/intc; ../../../..; ../../../enum/device; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/debug
    ../../../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/usb/_asf_v1/class/cdc/examples
    ../../../: cdc_example.c uart_usb_lib.c device_cdc_task.c host_cdc_task.c
  group avr32/services/usb/_asf_v1/class/cdc/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c
  group avr32/drivers/flashc
    ../../../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_task.c usb_host_enum.c
  group avr32/drivers/intc
    ../../../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c
  group avr32/drivers/gpio
    ../../../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../../../../drivers/usart/: usart.c
  group avr32/boards/evk1105
    ../../../../../../../../../boards/evk1105/: led.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: read.c write.c
  group common/services/fifo
    ../../../../../../../../../../common/services/fifo/: fifo.c
