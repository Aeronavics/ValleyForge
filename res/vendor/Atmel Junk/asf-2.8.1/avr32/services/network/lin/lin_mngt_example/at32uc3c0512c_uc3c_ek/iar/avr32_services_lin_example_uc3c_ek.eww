<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_lin_example_uc3c_ek.ewp</path>
	</project>
</workspace>
