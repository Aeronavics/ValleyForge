<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_services_network_can_example2_uc3c_ek.ewp</path>
	</project>
</workspace>
