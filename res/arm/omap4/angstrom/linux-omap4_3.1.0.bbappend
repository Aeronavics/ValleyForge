
FILESEXTRAPATHS_prepend := "${THISDIR}"

SRC_URI += "file://mcp2515.patch \
           "

PRINC := "1"
